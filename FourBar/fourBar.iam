# Autodesk Inventor assembly: fourBar
## iProperties
Created: 2008-10
Part Number: fourBar
Document SubType Name: Assembly
Designer: Lochan
Author: Lochan
